# Keil uVision project C30D_Relay_PC12_Test.uvprojx, settings and files
target 07_relay_pc12_test (6070000::V6.7::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: 07_relay_pc12_test +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32F407xx,PT_STAGE=7
  c misc: -std=c11 -Wall -Wextra -Werror
  c include: .\Core\Inc;.\BSP;.\Stages;.\Vendor\CMSIS\Include;.\Vendor\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\C30D.sct
  group Application
    ./Core/Src/: main.c pantilt_protocol.c pantilt_controller.c pantilt_app.c
  group C30D BSP
    ./BSP/: c30d_bsp_stm32f407.c
  group Stages
    ./Stages/: servo_single_test.c uart_protocol_test.c servo_sweep_test.c
  group CMSIS startup
    ./Vendor/Device/Source/: startup_stm32f407xx.s system_stm32f4xx.c
  group Configuration
    ./Core/Inc/: pantilt_config.h
    ./: C30D.sct
